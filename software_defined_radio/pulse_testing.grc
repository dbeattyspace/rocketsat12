<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import sys; sys.path.append('/usr/local/lib/python2.7/site-packages')</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>bw0</key><value>.010e9</value></param>
<param><key>freq0</key><value>2.710e9</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>pulse_pulse_detect</key>
<param><key>id</key><value>pulse_pulse_detect_0</value></param>
<param><key>average_multiple</key><value>1</value></param>
<param><key>sample_average</key><value>1</value></param>
</block>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>pulse_pulse_detect_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
